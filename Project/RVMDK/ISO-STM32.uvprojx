# Keil uVision project ISO-STM32.uvprojx, settings and files
target STM32F103ZE-Platform (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: luos.elf +hex
  BeforeMake: cmd /c python  ..\..\scripts\gen-version.py   ..\..\User\version.c
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER, USE_RX_SEM
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\FWlib\inc;..\..\User;..\..\User\APP;..\..\User\BSP;..\..\User\BSP\led;..\..\User\uC-CPU;..\..\User\uC-CPU\ARM-Cortex-M3\RealView;..\..\User\uC-LIB;..\..\User\uCOS-III\Source;..\..\User\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\..\User\BSP\i2c;..\..\User\BSP\adc;..\..\User\BSP\dac;..\..\User\BSP\internal_flash;..\..\User\BSP\485;..\..\User\BSP\usart;..\..\User\BSP\GeneralTim
  asm define: USE_RX_SEM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLIB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: stm32f10x_conf.h stm32f10x_it.h libSym.c linksym.c str.c
  group APP
    ../../User/: version.c cli_readline.c
    ../../init/: main.c
  group BSP
    ../../User/BSP/: bsp.h bsp_clkconfig.c bsp.c
    ../../User/BSP/led/: bsp_led.c
    ../../User/BSP/usart/: bsp_usart1.c
    ../../User/BSP/GeneralTim/: bsp_GeneralTim.c
  group luos
    ../../kernel/core/: coreLib.c memPartLib.c semBLib.c semCLib.c semLib.c semMLib.c taskLib.c timerLib.c msgQLib.c flagLib.c
    ../../arch/arm/: os-cpu-v7m3-timer.c
    ../../arch/arm/kernel/: os-cpu-v7m3.c os-cpu-v7m3.s
